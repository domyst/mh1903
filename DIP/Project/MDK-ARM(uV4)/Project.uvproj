# Keil uVision project Project.uvproj, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4
  c misc: --enum_is_int --c99
  c include: ..\..\BIOS\Libraries\Device\MegaHunt\mhscpu\Include;..\..\BIOS\Libraries\CMSIS\Include;..\..\BIOS\Libraries\MHSCPU_Driver\inc;..\..\App;..\..\BIOS\Libraries\MHSCPU_Driver\inc\emvlib;..\..\BIOS\Libraries\MHSCPU_Driver\lib\QR_normal
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x100000
  group App
    ../../App/: main.c systick.c mhscpu_it.c xpt2046.c ILI9488.c picture.c fonts.c beep.c calibration.c fnd.c DecodeDemo.c test_emv.c test_loopback.c rtc.c sound.c uart.c sam.c
  group MDK-ARM
    ../../BIOS/Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../BIOS/Libraries/MHSCPU_Driver/src/: misc.c mhscpu_dcmi.c mhscpu_dma.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_spi.c mhscpu_lcdi.c mhscpu_uart.c mhscpu_exti.c mhscpu_i2c.c mhscpu_timer.c mhscpu_emv_hard.c mhscpu_dac.c mhscpu_bpk.c mhscpu_rtc.c
  group CMSIS
    ../../BIOS/Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Lib
    ../../BIOS/Libraries/MHSCPU_Driver/lib/: MH1903_MSR.lib mh1903_emv.lib MH1903_GetCreditCardNum.lib
    ../../BIOS/Libraries/MHSCPU_Driver/lib/QR_normal/: MH1903_QRDecode.lib
target Primium (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4
  c misc: --enum_is_int --c99
  c include: ..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\..\..\Libraries\MHSCPU_Driver\inc\emvlib
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x100000
